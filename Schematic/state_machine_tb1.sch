** sch_path: Schematic/state_machine_tb1.sch
**.subckt state_machine_tb1 RST_Z START CLK_DATA DATA[5],DATA[4],DATA[3],DATA[2],DATA[1],DATA[0]
*+ EN_OFFSET_CAL CLK SINGLE_ENDED
*.ipin RST_Z
*.ipin START
*.opin CLK_DATA
*.opin DATA[5],DATA[4],DATA[3],DATA[2],DATA[1],DATA[0]
*.ipin EN_OFFSET_CAL
*.ipin CLK
*.ipin SINGLE_ENDED
**** begin user architecture code

VDD VDD 0 1.8
VSS VSS 0 0

VCLK CLK 0 PULSE(0 1.8 0 0.1n 0.1n 25n 50n)

* Reset active-low
VRST RST_Z 0 PWL(0 0 100n 0 100.1n 1.8)

VSTART START 0 PWL(0 0 120n 0 120.1n 1.8 170n 1.8 170.1n 0)

VENOFF EN_OFFSET_CAL 0 0
VSINGLE SINGLE_ENDED 0 0

VSIN COMP_P 0 SIN(0.9 0.9 50Meg 0 0)

VZ1 SMPL_ON_P 0 0
VZ2 SMPL_ON_N 0 0
VZ3 EN_VCM_SW 0 0
VZ4 EN_VOS_CAL 0 0
VZ5 OFFSET_CAL_CYCLE 0 0



.tran 0.2n 2u
.probe v(CLK) v(COMP_P) v(DATA0) v(DATA1) v(DATA2) v(CLK_DATA)
.end


.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice res_statistical
.lib $::180MCU_MODELS/smbb000149.ngspice typical




* Models for standard digital cells

.include $PDK_ROOT/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice


* Spice netlist for state machine generated by openlane
.include [xschem get current_dirname]/state_machine/openlane/runs/gf_run5/results/signoff/state_machine.spice



**** end user architecture code
**.ends
.end

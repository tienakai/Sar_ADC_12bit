** sch_path: Schematic/top_tb.sch
**.subckt top_tb
x1 VDD VCM VSS VREF VIN_P VIN_N RST_Z CLK_DATA DATA[5] DATA[4] DATA[3] DATA[2] DATA[1] DATA[0] START
+ EN_OFFSET_CAL CLK VREF_GND SINGLE_ENDED SAR_ADC_12bit
V1 VDD VSS {VDD}
.save i(v1)
V2 net1 VSS {VCM}
.save i(v2)
V3 net2 VSS {VREF}
.save i(v3)
V4 VSS GND 0
V7 START VSS {VDD}
V8 RST_Z VSS pwl(0 0 10n 0 10.1n {VDD})
V5 net4 VSS sin({VCM} {VREF/2} {f_in} 0 0 0)
R1 net1 VCM 500 m=1
V9 CLK VSS pulse(0 {VDD} 0 1n 1n {1/(16*f_sample)-10n} {1/(16*f_sample)})
V6 net5 VSS sin({VCM} {VREF/2} {f_in} 0 0 180)
V10 net3 VSS {VREF_GND}
.save i(v10)
R6 net2 VREF 500 m=1
R7 net3 VREF_GND 500 m=1
R8 net4 VIN_P 500 m=1
R9 net5 VIN_N 500 m=1
V11 EN_OFFSET_CAL VSS 0
V12 SINGLE_ENDED VSS 0
**** begin user architecture code


* Supply, common mode and reference voltage
.param VDD = 1.8
.param VREF = 1.2
.param VREF_GND = 0
.param VCM = 0.6

.option temp = 27

* Input and sampling frequencies
* For coherent sampling f_in is calculated
.param n_window = 67
.param n_fft = 256
.param f_sample = 1.25Meg
.param f_in = {f_sample*n_window/n_fft}


.control

		tran 10n 208u
		write top_level_enob_sim.raw
.endc



.include $::180MCU_MODELS/design.ngspice
.lib $::180MCU_MODELS/sm141064.ngspice typical
.lib $::180MCU_MODELS/sm141064.ngspice cap_mim
.lib $::180MCU_MODELS/sm141064.ngspice res_typical
.lib $::180MCU_MODELS/sm141064.ngspice moscap_typical
.lib $::180MCU_MODELS/sm141064.ngspice mimcap_typical
.lib $::180MCU_MODELS/sm141064.ngspice res_statistical
.lib $::180MCU_MODELS/smbb000149.ngspice typical



.include $PDK_ROOT/gf180mcuD/libs.ref/gf180mcu_fd_sc_mcu7t5v0/spice/gf180mcu_fd_sc_mcu7t5v0.spice

* Spice netlist for state machine generated by openlane
.include [xschem get current_dirname]/state_machine/openlane/runs/gf_run5/results/signoff/state_machine.spice
.include [xschem get current_dirname]/CDAC/CADC_12bit.spice



**** end user architecture code
**.ends
.end
